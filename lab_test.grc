options:
  parameters:
    author: edwin
    generate_options: qt_gui
    id: lab_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    start: 2402e6
    step: 1e6
    stop: 2480e6
    value: 2432e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: trigger
  id: variable_qtgui_range
  parameters:
    label: trigger
    start: '-100'
    step: '1'
    stop: '0'
    value: '-15'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '5e-3'
    gate: 'True'
    ramp: '0'
    threshold: trigger
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_file_sink_0_3
  id: blocks_file_sink
  parameters:
    file: /home/edwin/channel5.bin
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '40000000'
    type: complex
  states: {state: disabled}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.001'
    gain_mu: '0.175'
    mu: '0.01'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import csv\nimport numpy\nimport pmt\nfrom gnuradio import gr\n\nclass selective_save(gr.sync_block):\n    def __init__(self, filepath='output.csv', sampling_rate=1e6):\n        gr.sync_block.__init__(\n            self,\n            name=\"Selective Save\",\n            in_sig=[numpy.float32],\n            out_sig=None\n        )\n        self.filepath = filepath\n        self.sampling_rate = sampling_rate\n        self.duration_samples = int((100e-6) * self.sampling_rate)  # 100 us worth of samples\n        self.squelch_active = False\n        self.sample_count = 0\n        self.csvfile = open(self.filepath, 'w', newline='')\n        self.csvwriter = csv.writer(self.csvfile, delimiter=',')\n        self.index = 1\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        ninput_items = len(in0)\n        tags = self.get_tags_in_window(0, 0, ninput_items)\n\n        # Check for squelch_sob tag to activate recording\n        for tag in tags:\n            key = pmt.symbol_to_string(tag.key)\n            if key == 'squelch_sob':\n                self.squelch_active = True\n                self.sample_count = 0\n\n        # If squelch is active and we haven't reached the desired duration, record data\n        if self.squelch_active:\n            end_idx = min(ninput_items, self.sample_count + self.duration_samples)\n            for idx in range(self.sample_count, end_idx):\n                value = in0[idx]\n                # Only save values within -0.5 to 0.5\n                if -0.15 <= value <= 0.15:\n                    self.csvwriter.writerow([value, self.index])\n                    self.index += 1\n            self.sample_count += ninput_items\n\n            # Stop recording if we've reached the duration limit\n            if self.sample_count >= self.duration_samples:\n                self.squelch_active = False\n\n        return ninput_items\n\n    def stop(self):\n        self.csvfile.close()\n        return True\n\n"
    filepath: '"/home/edwin/Downloads/plotting.csv"'
    sampling_rate: 4e6
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: "import csv\nimport numpy as np \nimport pmt\nfrom gnuradio import gr\n\nclass selective_save(gr.sync_block):\n    def __init__(self, filepath='output.csv', sampling_rate=1e6, median_symbols=100):\n        gr.sync_block.__init__(\n            self,\n            name=\"Selective Save\",\n            in_sig=[np.float32],\n            out_sig=None\n        )\n        self.filepath = filepath\n        self.sampling_rate = sampling_rate\n        self.duration_samples = int((50e-6) * self.sampling_rate)  # 100 us worth of samples\n        self.median_symbols = median_symbols\n        self.squelch_active = False\n        self.sample_count = 0\n        self.positive_phases = []\n        self.negative_phases = []\n        self.data_points = []\n        self.csvfile = open(self.filepath, 'w', newline='')\n        self.csvwriter = csv.writer(self.csvfile, delimiter=',')\n        self.index = 1\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        ninput_items = len(in0)\n        tags = self.get_tags_in_window(0, 0, ninput_items)\n\n        # Check for squelch_sob tag to activate recording\n        for tag in tags:\n            key = pmt.symbol_to_string(tag.key)\n            if key == 'squelch_sob':\n                self.squelch_active = True\n                self.sample_count = 0\n\n        # If squelch is active and we haven't reached the desired duration, record data\n        if self.squelch_active:\n            end_idx = min(ninput_items, self.sample_count + self.duration_samples)\n            for idx in range(self.sample_count, end_idx):\n                value = in0[idx]\n                # Only save values within -0.5 to 0.5\n                if -0.15 <= value <= 0.15:\n                    if value > 0:\n                        self.positive_phases.append(value)\n                    elif value < 0:\n                        self.negative_phases.append(value)\n            self.sample_count += ninput_items\n\n            # Stop recording if we've reached the duration limit\n            if self.sample_count >= self.duration_samples:\n                self.squelch_active = False\n\n        # Proceed with calculations if enough data points are collected\n        if len(self.positive_phases) > self.median_symbols and len(self.negative_phases) > self.median_symbols:\n            pos_quantile = np.median(self.positive_phases)\n            neg_quantile = np.median(self.negative_phases)\n            cfo = (pos_quantile + neg_quantile) / 2\n            deviation = (pos_quantile - cfo)\n\n            # Write calculations to CSV\n            self.csvwriter.writerow([cfo, deviation])\n            \n            # Reset the lists\n            self.positive_phases = []\n            self.negative_phases = []\n\n        return ninput_items\n\n    def stop(self):\n        self.csvfile.close()\n        return True\n\n"
    filepath: '"/home/edwin/Downloads/IphoneSE_2022_3Gen.csv"'
    median_symbols: '100'
    sampling_rate: 4e6
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, 4e6, -0.5e6, 0.5e6, 50e3, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, 4e6, -0.5e6, 0.5e6, 150e3, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"phase demod"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: freq
    gain: '20'
    samp_rate: samp_rate
    type: fc32
    vga: '20'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_complex_to_arg_0, '0']
- [analog_pwr_squelch_xx_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_const_sink_x_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_arg_1, '0', epy_block_1_0, '0']
- [blocks_complex_to_arg_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_correctiq_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_head_0, '0', digital_gfsk_demod_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_complex_to_arg_1, '0']
- [blocks_magphase_to_complex_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_sub_xx_0, '0', blocks_magphase_to_complex_0, '1']
- [digital_gfsk_demod_0, '0', blocks_file_sink_0_3, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_head_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', digital_gfsk_demod_0, '0']
- [soapy_hackrf_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
