options:
  parameters:
    author: edwin
    generate_options: qt_gui
    id: bluetoothSniffer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandpass_filter
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: 500e3
    low_cutoff_freq: '-500e3'
    samp_rate: samp_rate
    type: complex_band_pass
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: bandwith_channel
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    label: center_freq
    type: int
    value: '2440'
  states: {}
- name: fft_length
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '49'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: trigger
  id: variable_qtgui_range
  parameters:
    label: trigger
    start: '-100'
    step: '1'
    stop: '0'
    value: '-15'
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_0_2
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_0_3
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '100e-6'
    gate: 'True'
    ramp: '0'
    threshold: trigger
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '100e-6'
    gate: 'True'
    ramp: '0'
    threshold: trigger
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: trigger
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_2
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: trigger
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_2_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '100e-6'
    gate: 'True'
    ramp: '0'
    threshold: trigger
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_2
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_3
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1_2
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1_3
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/edwin/channel2.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/edwin/channel1.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/edwin/channel3.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: /home/edwin/channel4.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_3
  id: blocks_file_sink
  parameters:
    file: /home/edwin/channel5.bin
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '120000000'
    type: complex
  states: {state: disabled}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_magphase_to_complex_0_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_magphase_to_complex_0_1
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_magphase_to_complex_0_2
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_magphase_to_complex_0_3
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_3
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_3
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.01'
    gain_mu: '0.175'
    mu: '0.320'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '2.546479'
  states: {}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.01'
    gain_mu: '0.175'
    mu: '0.320'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '2.546479'
  states: {}
- name: digital_gfsk_demod_0_1
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.01'
    gain_mu: '0.175'
    mu: '0.320'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '2.546479'
  states: {}
- name: digital_gfsk_demod_0_2
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.01'
    gain_mu: '0.175'
    mu: '0.320'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '2.546479'
  states: {}
- name: digital_gfsk_demod_0_2_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.01'
    gain_mu: '0.175'
    mu: '0.320'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '2.546479'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: "import csv\nimport numpy as np \nimport pmt\nfrom gnuradio import gr\n\nclass selective_save(gr.sync_block):\n    def __init__(self, filepath='output.csv', sampling_rate=1e6, median_symbols=100):\n        gr.sync_block.__init__(\n            self,\n            name=\"Selective Save\",\n            in_sig=[np.float32],\n            out_sig=None\n        )\n        self.filepath = filepath\n        self.sampling_rate = sampling_rate\n        self.duration_samples = int((200e-6) * self.sampling_rate)  # 100 us worth of samples\n        self.median_symbols = median_symbols\n        self.squelch_active = False\n        self.sample_count = 0\n        self.positive_phases = []\n        self.negative_phases = []\n        self.data_points = []\n        self.csvfile = open(self.filepath, 'w', newline='')\n        self.csvwriter = csv.writer(self.csvfile, delimiter=',')\n        self.index = 1\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        ninput_items = len(in0)\n        tags = self.get_tags_in_window(0, 0, ninput_items)\n\n        # Check for squelch_sob tag to activate recording\n        for tag in tags:\n            key = pmt.symbol_to_string(tag.key)\n            if key == 'squelch_sob':\n                self.squelch_active = True\n                self.sample_count = 0\n\n        # If squelch is active and we haven't reached the desired duration, record data\n        if self.squelch_active:\n            end_idx = min(ninput_items, self.sample_count + self.duration_samples)\n            for idx in range(self.sample_count, end_idx):\n                value = in0[idx]\n                # Only save values within -0.5 to 0.5\n                if -0.15 <= value <= 0.15:\n                    if value > 0:\n                        self.positive_phases.append(value)\n                    elif value < 0:\n                        self.negative_phases.append(value)\n            self.sample_count += ninput_items\n\n            # Stop recording if we've reached the duration limit\n            if self.sample_count >= self.duration_samples:\n                self.squelch_active = False\n\n        # Proceed with calculations if enough data points are collected\n        if len(self.positive_phases) > self.median_symbols and len(self.negative_phases) > self.median_symbols:\n            pos_quantile = np.median(self.positive_phases)\n            neg_quantile = np.median(self.negative_phases)\n            cfo = (pos_quantile + neg_quantile) / 2\n            deviation = (pos_quantile - cfo)\n\n            # Write calculations to CSV\n            self.csvwriter.writerow([cfo, deviation])\n            \n            # Reset the lists\n            self.positive_phases = []\n            self.negative_phases = []\n\n        return ninput_items\n\n    def stop(self):\n        self.csvfile.close()\n        return True\n\n"
    filepath: '"/home/edwin/Downloads/channel3_CFO_DEV.csv"'
    median_symbols: '200'
    sampling_rate: 4e6
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: "import csv\nimport numpy as np \nimport pmt\nfrom gnuradio import gr\n\nclass selective_save(gr.sync_block):\n    def __init__(self, filepath='output.csv', sampling_rate=1e6, median_symbols=100):\n        gr.sync_block.__init__(\n            self,\n            name=\"Selective Save\",\n            in_sig=[np.float32],\n            out_sig=None\n        )\n        self.filepath = filepath\n        self.sampling_rate = sampling_rate\n        self.duration_samples = int((200e-6) * self.sampling_rate)  # 100 us worth of samples\n        self.median_symbols = median_symbols\n        self.squelch_active = False\n        self.sample_count = 0\n        self.positive_phases = []\n        self.negative_phases = []\n        self.data_points = []\n        self.csvfile = open(self.filepath, 'w', newline='')\n        self.csvwriter = csv.writer(self.csvfile, delimiter=',')\n        self.index = 1\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        ninput_items = len(in0)\n        tags = self.get_tags_in_window(0, 0, ninput_items)\n\n        # Check for squelch_sob tag to activate recording\n        for tag in tags:\n            key = pmt.symbol_to_string(tag.key)\n            if key == 'squelch_sob':\n                self.squelch_active = True\n                self.sample_count = 0\n\n        # If squelch is active and we haven't reached the desired duration, record data\n        if self.squelch_active:\n            end_idx = min(ninput_items, self.sample_count + self.duration_samples)\n            for idx in range(self.sample_count, end_idx):\n                value = in0[idx]\n                # Only save values within -0.5 to 0.5\n                if -0.15 <= value <= 0.15:\n                    if value > 0:\n                        self.positive_phases.append(value)\n                    elif value < 0:\n                        self.negative_phases.append(value)\n            self.sample_count += ninput_items\n\n            # Stop recording if we've reached the duration limit\n            if self.sample_count >= self.duration_samples:\n                self.squelch_active = False\n\n        # Proceed with calculations if enough data points are collected\n        if len(self.positive_phases) > self.median_symbols and len(self.negative_phases) > self.median_symbols:\n            pos_quantile = np.median(self.positive_phases)\n            neg_quantile = np.median(self.negative_phases)\n            cfo = (pos_quantile + neg_quantile) / 2\n            deviation = (pos_quantile - cfo)\n\n            # Write calculations to CSV\n            self.csvwriter.writerow([cfo, deviation])\n            \n            # Reset the lists\n            self.positive_phases = []\n            self.negative_phases = []\n\n        return ninput_items\n\n    def stop(self):\n        self.csvfile.close()\n        return True\n\n"
    filepath: '"/home/edwin/Downloads/channel2_CFO_DEV.csv"'
    median_symbols: '200'
    sampling_rate: 4e6
  states: {}
- name: epy_block_1_0_1
  id: epy_block
  parameters:
    _source_code: "import csv\nimport numpy as np \nimport pmt\nfrom gnuradio import gr\n\nclass selective_save(gr.sync_block):\n    def __init__(self, filepath='output.csv', sampling_rate=1e6, median_symbols=100):\n        gr.sync_block.__init__(\n            self,\n            name=\"Selective Save\",\n            in_sig=[np.float32],\n            out_sig=None\n        )\n        self.filepath = filepath\n        self.sampling_rate = sampling_rate\n        self.duration_samples = int((200e-6) * self.sampling_rate)  # 100 us worth of samples\n        self.median_symbols = median_symbols\n        self.squelch_active = False\n        self.sample_count = 0\n        self.positive_phases = []\n        self.negative_phases = []\n        self.data_points = []\n        self.csvfile = open(self.filepath, 'w', newline='')\n        self.csvwriter = csv.writer(self.csvfile, delimiter=',')\n        self.index = 1\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        ninput_items = len(in0)\n        tags = self.get_tags_in_window(0, 0, ninput_items)\n\n        # Check for squelch_sob tag to activate recording\n        for tag in tags:\n            key = pmt.symbol_to_string(tag.key)\n            if key == 'squelch_sob':\n                self.squelch_active = True\n                self.sample_count = 0\n\n        # If squelch is active and we haven't reached the desired duration, record data\n        if self.squelch_active:\n            end_idx = min(ninput_items, self.sample_count + self.duration_samples)\n            for idx in range(self.sample_count, end_idx):\n                value = in0[idx]\n                # Only save values within -0.5 to 0.5\n                if -0.15 <= value <= 0.15:\n                    if value > 0:\n                        self.positive_phases.append(value)\n                    elif value < 0:\n                        self.negative_phases.append(value)\n            self.sample_count += ninput_items\n\n            # Stop recording if we've reached the duration limit\n            if self.sample_count >= self.duration_samples:\n                self.squelch_active = False\n\n        # Proceed with calculations if enough data points are collected\n        if len(self.positive_phases) > self.median_symbols and len(self.negative_phases) > self.median_symbols:\n            pos_quantile = np.median(self.positive_phases)\n            neg_quantile = np.median(self.negative_phases)\n            cfo = (pos_quantile + neg_quantile) / 2\n            deviation = (pos_quantile - cfo)\n\n            # Write calculations to CSV\n            self.csvwriter.writerow([cfo, deviation])\n            \n            # Reset the lists\n            self.positive_phases = []\n            self.negative_phases = []\n\n        return ninput_items\n\n    def stop(self):\n        self.csvfile.close()\n        return True\n\n"
    filepath: '"/home/edwin/Downloads/channel1_CFO_DEV.csv"'
    median_symbols: '200'
    sampling_rate: 4e6
  states: {}
- name: epy_block_1_0_2
  id: epy_block
  parameters:
    _source_code: "import csv\nimport numpy as np \nimport pmt\nfrom gnuradio import gr\n\nclass selective_save(gr.sync_block):\n    def __init__(self, filepath='output.csv', sampling_rate=1e6, median_symbols=100):\n        gr.sync_block.__init__(\n            self,\n            name=\"Selective Save\",\n            in_sig=[np.float32],\n            out_sig=None\n        )\n        self.filepath = filepath\n        self.sampling_rate = sampling_rate\n        self.duration_samples = int((200e-6) * self.sampling_rate)  # 100 us worth of samples\n        self.median_symbols = median_symbols\n        self.squelch_active = False\n        self.sample_count = 0\n        self.positive_phases = []\n        self.negative_phases = []\n        self.data_points = []\n        self.csvfile = open(self.filepath, 'w', newline='')\n        self.csvwriter = csv.writer(self.csvfile, delimiter=',')\n        self.index = 1\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        ninput_items = len(in0)\n        tags = self.get_tags_in_window(0, 0, ninput_items)\n\n        # Check for squelch_sob tag to activate recording\n        for tag in tags:\n            key = pmt.symbol_to_string(tag.key)\n            if key == 'squelch_sob':\n                self.squelch_active = True\n                self.sample_count = 0\n\n        # If squelch is active and we haven't reached the desired duration, record data\n        if self.squelch_active:\n            end_idx = min(ninput_items, self.sample_count + self.duration_samples)\n            for idx in range(self.sample_count, end_idx):\n                value = in0[idx]\n                # Only save values within -0.5 to 0.5\n                if -0.15 <= value <= 0.15:\n                    if value > 0:\n                        self.positive_phases.append(value)\n                    elif value < 0:\n                        self.negative_phases.append(value)\n            self.sample_count += ninput_items\n\n            # Stop recording if we've reached the duration limit\n            if self.sample_count >= self.duration_samples:\n                self.squelch_active = False\n\n        # Proceed with calculations if enough data points are collected\n        if len(self.positive_phases) > self.median_symbols and len(self.negative_phases) > self.median_symbols:\n            pos_quantile = np.median(self.positive_phases)\n            neg_quantile = np.median(self.negative_phases)\n            cfo = (pos_quantile + neg_quantile) / 2\n            deviation = (pos_quantile - cfo)\n\n            # Write calculations to CSV\n            self.csvwriter.writerow([cfo, deviation])\n            \n            # Reset the lists\n            self.positive_phases = []\n            self.negative_phases = []\n\n        return ninput_items\n\n    def stop(self):\n        self.csvfile.close()\n        return True\n\n"
    filepath: '"/home/edwin/Downloads/channel4_CFO_DEV.csv"'
    median_symbols: '200'
    sampling_rate: 4e6
  states: {}
- name: epy_block_1_0_3
  id: epy_block
  parameters:
    _source_code: "import csv\nimport numpy as np \nimport pmt\nfrom gnuradio import gr\n\nclass selective_save(gr.sync_block):\n    def __init__(self, filepath='output.csv', sampling_rate=1e6, median_symbols=100):\n        gr.sync_block.__init__(\n            self,\n            name=\"Selective Save\",\n            in_sig=[np.float32],\n            out_sig=None\n        )\n        self.filepath = filepath\n        self.sampling_rate = sampling_rate\n        self.duration_samples = int((200e-6) * self.sampling_rate)  # 100 us worth of samples\n        self.median_symbols = median_symbols\n        self.squelch_active = False\n        self.sample_count = 0\n        self.positive_phases = []\n        self.negative_phases = []\n        self.data_points = []\n        self.csvfile = open(self.filepath, 'w', newline='')\n        self.csvwriter = csv.writer(self.csvfile, delimiter=',')\n        self.index = 1\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        ninput_items = len(in0)\n        tags = self.get_tags_in_window(0, 0, ninput_items)\n\n        # Check for squelch_sob tag to activate recording\n        for tag in tags:\n            key = pmt.symbol_to_string(tag.key)\n            if key == 'squelch_sob':\n                self.squelch_active = True\n                self.sample_count = 0\n\n        # If squelch is active and we haven't reached the desired duration, record data\n        if self.squelch_active:\n            end_idx = min(ninput_items, self.sample_count + self.duration_samples)\n            for idx in range(self.sample_count, end_idx):\n                value = in0[idx]\n                # Only save values within -0.5 to 0.5\n                if -0.15 <= value <= 0.15:\n                    if value > 0:\n                        self.positive_phases.append(value)\n                    elif value < 0:\n                        self.negative_phases.append(value)\n            self.sample_count += ninput_items\n\n            # Stop recording if we've reached the duration limit\n            if self.sample_count >= self.duration_samples:\n                self.squelch_active = False\n\n        # Proceed with calculations if enough data points are collected\n        if len(self.positive_phases) > self.median_symbols and len(self.negative_phases) > self.median_symbols:\n            pos_quantile = np.median(self.positive_phases)\n            neg_quantile = np.median(self.negative_phases)\n            cfo = (pos_quantile + neg_quantile) / 2\n            deviation = (pos_quantile - cfo)\n\n            # Write calculations to CSV\n            self.csvwriter.writerow([cfo, deviation])\n            \n            # Reset the lists\n            self.positive_phases = []\n            self.negative_phases = []\n\n        return ninput_items\n\n    def stop(self):\n        self.csvfile.close()\n        return True\n\n"
    filepath: '"/home/edwin/Downloads/channel5_CFO_DEV.csv"'
    median_symbols: '200'
    sampling_rate: 4e6
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class my_basic_adder_block(gr.basic_block):
          def __init__(self,tag_name = 'packet_len'):
              gr.basic_block.__init__(self,
                                      name="Tagged Stream Cropper",
                                      in_sig  = [np.complex64],
                                      out_sig = [np.complex64])

              self.previous_tag_n_remainder = 0
              self.tag_name = tag_name
              self.set_tag_propagation_policy(gr.TPP_DONT)


          def general_work(self, input_items, output_items):
              len_out = len(output_items[0])

              # DO PROCESSING
              out_produced = 0 # output produced 

              #-> Write the remaining data of the previous tag
              if self.previous_tag_n_remainder > 0: 
                  if self.previous_tag_n_remainder < len_out: # if the length of the input items is sufficient to write the remainder of the previous tag items 
                      output_items[0][:self.previous_tag_n_remainder] = input_items[0][:self.previous_tag_n_remainder] #write to output 
                      out_produced                                   += self.previous_tag_n_remainder                  #inccrease the number of item produced
                      self.previous_tag_n_remainder = 0                                                                #reset the counter 
                      # the RETURN is at the end of the work()

                  else: # self.previous_tag_n_remainder >= len_out
                      output_items[0][:len_out]      = input_items[0][:len_out]
                      self.previous_tag_n_remainder -= len_out
                      self.consume(0, len_out)
                      return len_out

              # READ TAGS AND PARSE THE RECEIVED STREAM
              tags = self.get_tags_in_window(0, out_produced, len_out)

              #if there exist tag
              if len(tags) > 0:
                  #for each tag apply
                  for tag in tags:
                      tag_name = pmt.to_python(tag.key)            # packet_tag
                      tag_len = pmt.to_python(tag.value)          # packet_len
                      tag_pos = tag.offset - self.nitems_read(0)  # packet_position_index
                      if tag_name == self.tag_name:       #check if the tag name is appropriate
                          if tag_pos + tag_len < len_out: # if all the elements correspding to the "tag" are included in the input_items

                              # write the elements to the output
                              output_items[0][out_produced:(out_produced+tag_len)] = input_items[0][tag_pos:(tag_pos+tag_len)]

                              # add tag to the corresponding start point                     
                              self.add_item_tag(0,                                   # Write to output port 0
                                               self.nitems_written(0)+out_produced,  # Index of the tag in absolute terms
                                               tag.key,                              # Key of the tag
                                               tag.value                             # Value of the tag
                                               )
                              #increase the number of output element produced counter
                              out_produced += tag_len

                          else: #tag_pos+tag_len >= len_out:
                              n_item_to_wrt = len_out - tag_pos
                              output_items[0][out_produced:(out_produced + n_item_to_wrt)] = input_items[0][tag_pos:(tag_pos+n_item_to_wrt)]

                              self.add_item_tag(0,                                     # Write to output port 0
                                                self.nitems_written(0)+out_produced,   # Index of the tag in absolute terms
                                                tag.key,                               # Key of the tag
                                                tag.value                              # Value of the tag
                                                )

                              self.previous_tag_n_remainder = tag_len - n_item_to_wrt
                              out_produced                 += n_item_to_wrt
                              self.consume(0,len_out)
                              return out_produced

              #if there is no tag exits
              self.consume(0,len_out)

              #recall that the first "if" state is producing element!
              return out_produced
    tag_name: '''packet_len'''
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: 4e6
    taps: firdes.complex_band_pass(1, 4e6, -0.5e6, 0.5e6, 50e3, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: 4e6
    taps: firdes.complex_band_pass(1, 4e6, -0.5e6, 0.5e6, 50e3, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: 4e6
    taps: firdes.complex_band_pass(1, 4e6, -0.5e6, 0.5e6, 50e3, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: 4e6
    taps: firdes.complex_band_pass(1, 4e6, -0.5e6, 0.5e6, 50e3, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_3_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: 4e6
    taps: firdes.complex_band_pass(1, 4e6, -0.5e6, 0.5e6, 50e3, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: pfb_channelizer_ccf_1
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    nchans: '6'
    osr: '2.0'
    taps: firdes.low_pass(1, 12e6, 100e3, 500e3, window.WIN_HANN)
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 1e6
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"cannel4"'
    tr_level: trigger
    type: complex
    wintype: window.WIN_HANN
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    bandwidth: 6e6
    center_freq: 2432e6
    gain: gain
    samp_rate: 12e6
    type: fc32
    vga: gain
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [analog_const_source_x_0_0, '0', blocks_magphase_to_complex_0_0, '0']
- [analog_const_source_x_0_1, '0', blocks_magphase_to_complex_0_1, '0']
- [analog_const_source_x_0_2, '0', blocks_magphase_to_complex_0_2, '0']
- [analog_const_source_x_0_3, '0', blocks_magphase_to_complex_0_3, '0']
- [analog_pwr_squelch_xx_0_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [analog_pwr_squelch_xx_0_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_pwr_squelch_xx_0_1, '0', freq_xlating_fir_filter_xxx_2, '0']
- [analog_pwr_squelch_xx_0_2, '0', freq_xlating_fir_filter_xxx_3, '0']
- [analog_pwr_squelch_xx_0_2_0, '0', freq_xlating_fir_filter_xxx_3_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_delay_0_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_complex_to_arg_0_1, '0', blocks_delay_0_1, '0']
- [blocks_complex_to_arg_0_1, '0', blocks_sub_xx_0_1, '0']
- [blocks_complex_to_arg_0_2, '0', blocks_delay_0_2, '0']
- [blocks_complex_to_arg_0_2, '0', blocks_sub_xx_0_2, '0']
- [blocks_complex_to_arg_0_3, '0', blocks_delay_0_3, '0']
- [blocks_complex_to_arg_0_3, '0', blocks_sub_xx_0_3, '0']
- [blocks_complex_to_arg_1, '0', epy_block_1_0, '0']
- [blocks_complex_to_arg_1_0, '0', epy_block_1_0_0, '0']
- [blocks_complex_to_arg_1_1, '0', epy_block_1_0_1, '0']
- [blocks_complex_to_arg_1_2, '0', epy_block_1_0_2, '0']
- [blocks_complex_to_arg_1_3, '0', epy_block_1_0_3, '0']
- [blocks_correctiq_0, '0', blocks_head_0, '0']
- [blocks_correctiq_0, '0', pfb_channelizer_ccf_1, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_delay_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_delay_0_1, '0', blocks_sub_xx_0_1, '1']
- [blocks_delay_0_2, '0', blocks_sub_xx_0_2, '1']
- [blocks_delay_0_3, '0', blocks_sub_xx_0_3, '1']
- [blocks_head_0, '0', pfb_channelizer_ccf_1, '0']
- [blocks_magphase_to_complex_0, '0', blocks_complex_to_arg_1, '0']
- [blocks_magphase_to_complex_0_0, '0', blocks_complex_to_arg_1_0, '0']
- [blocks_magphase_to_complex_0_1, '0', blocks_complex_to_arg_1_1, '0']
- [blocks_magphase_to_complex_0_2, '0', blocks_complex_to_arg_1_2, '0']
- [blocks_magphase_to_complex_0_3, '0', blocks_complex_to_arg_1_3, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0_3, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_repack_bits_bb_0_1, '0', blocks_file_sink_0_0, '0']
- [blocks_repack_bits_bb_0_2, '0', blocks_file_sink_0_2, '0']
- [blocks_repack_bits_bb_0_3, '0', blocks_file_sink_0_1, '0']
- [blocks_sub_xx_0, '0', blocks_magphase_to_complex_0, '1']
- [blocks_sub_xx_0_0, '0', blocks_magphase_to_complex_0_0, '1']
- [blocks_sub_xx_0_1, '0', blocks_magphase_to_complex_0_1, '1']
- [blocks_sub_xx_0_2, '0', blocks_magphase_to_complex_0_2, '1']
- [blocks_sub_xx_0_3, '0', blocks_magphase_to_complex_0_3, '1']
- [digital_gfsk_demod_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_gfsk_demod_0_0, '0', blocks_repack_bits_bb_0_1, '0']
- [digital_gfsk_demod_0_1, '0', blocks_repack_bits_bb_0_3, '0']
- [digital_gfsk_demod_0_2, '0', blocks_repack_bits_bb_0_2, '0']
- [digital_gfsk_demod_0_2_0, '0', blocks_repack_bits_bb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_arg_0_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', digital_gfsk_demod_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', blocks_complex_to_arg_0_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', digital_gfsk_demod_0_0, '0']
- [freq_xlating_fir_filter_xxx_2, '0', blocks_complex_to_arg_0, '0']
- [freq_xlating_fir_filter_xxx_2, '0', digital_gfsk_demod_0_1, '0']
- [freq_xlating_fir_filter_xxx_3, '0', blocks_complex_to_arg_0_2, '0']
- [freq_xlating_fir_filter_xxx_3, '0', digital_gfsk_demod_0_2, '0']
- [freq_xlating_fir_filter_xxx_3, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_3_0, '0', blocks_complex_to_arg_0_3, '0']
- [freq_xlating_fir_filter_xxx_3_0, '0', digital_gfsk_demod_0_2_0, '0']
- [freq_xlating_fir_filter_xxx_3_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [pfb_channelizer_ccf_1, '0', analog_pwr_squelch_xx_0_0_0, '0']
- [pfb_channelizer_ccf_1, '1', analog_pwr_squelch_xx_0_0, '0']
- [pfb_channelizer_ccf_1, '2', analog_pwr_squelch_xx_0_1, '0']
- [pfb_channelizer_ccf_1, '3', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_1, '4', analog_pwr_squelch_xx_0_2, '0']
- [pfb_channelizer_ccf_1, '5', analog_pwr_squelch_xx_0_2_0, '0']
- [soapy_hackrf_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
